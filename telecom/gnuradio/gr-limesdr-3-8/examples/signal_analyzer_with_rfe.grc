options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Signal analyzer
  states: {}

blocks:
- name: analog_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Analog filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6
  states: {}
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RX Baseband [MHz]
    type: real
    value: '446.094'
  states: {}
- name: digital_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Digital filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6 - 0.3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: LNA Path
    label0: Auto
    label1: H
    label2: L
    label3: W
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '255'
  states: {}
- name: nco
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: NCO [MHz]
    type: real
    value: '0'
  states: {}
- name: rfe_attenuation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,1,1,1
    label: RFE Attenuation [dB]
    labels: '[''0'', ''2'', ''4'', ''6'', ''8'', ''10'', ''12'', ''14'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5 ,6 , 7]'
    type: int
    value: '0'
  states: {}
- name: rfe_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label: LimeRFE Mode
    label0: RX
    label1: NONE
    label2: TXRX
    num_opts: '3'
    option1: '2'
    option2: '3'
    type: int
    value: '0'
  states: {}
- name: rfe_notch
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,1
    label: AM/FM Notch Filter
    label0: Enabled
    label1: Disabled
    num_opts: '2'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: limesdr_rfe_0
  id: limesdr_rfe
  parameters:
    atten: rfe_attenuation
    comm_type: '1'
    mode: rfe_mode
    notch: rfe_notch
    rx_channel: '-2'
    rx_port: '1'
    tx_channel: '-2'
    tx_port: '2'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: analog_filter*1e6
    calibr_bandw_ch0: samp_rate
    channel_mode: '0'
    digital_bandw_ch0: digital_filter*1e6
    gain_dB_ch0: gain
    lna_path_ch0: lna_path
    lna_path_ch1: '1'
    nco_freq_ch0: nco
    oversample: '0'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '4096'
    gui_hint: 5,0,2,2
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
