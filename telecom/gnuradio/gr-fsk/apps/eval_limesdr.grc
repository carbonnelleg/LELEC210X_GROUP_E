options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: eval_limesdr
    output_language: python
    title: LELEC2102 - Decode SDR
  states: {}

blocks:
- name: Enable_detection
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: crc_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: detect_threshold_entry
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: detect_threshold_entry
  id: variable_qtgui_entry
  parameters:
    label: Detection Threshold
    type: real
    value: '1e-3'
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/2
  states: {}
- name: hdr_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: noiseQuery
  id: variable_qtgui_push_button
  parameters:
    label: Noise estimation query
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: hdr_len+payload_len+crc_len
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: print_metrics
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: print_payload
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: '10'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*8
  states: {}
- name: save_measurements
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: tx_power
  id: variable_qtgui_entry
  parameters:
    label: TX power used (no impact, just for logging)
    type: int
    value: '0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: fsk_demodulation_0
  id: fsk_demodulation
  parameters:
    crc_len: crc_len
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    payload_len: payload_len
  states: {}
- name: fsk_logger_0
  id: fsk_logger
  parameters:
    meas_type: eval_radio
    payload_len: payload_len
    print_metrics: print_metrics
    print_payload: print_payload
    save_measurements: save_measurements
  states: {}
- name: fsk_onQuery_noise_estimation_0
  id: fsk_onQuery_noise_estimation
  parameters:
    n_est: '10'
    n_samples: '1024'
    query: noiseQuery
  states: {}
- name: fsk_packet_parser_0
  id: fsk_packet_parser
  parameters:
    address: '[0,0,1,1,1,1,1,0,0,0,1,0,1,0,1,0,0,1,0,1,0,1,0,0,1,0,1,1,0,1,1,1]'
    crc_len: crc_len
    hdr_len: hdr_len
    payload_len: payload_len
  states: {}
- name: fsk_preamble_detect_0
  id: fsk_preamble_detect
  parameters:
    drate: data_rate
    enable: Enable_detection
    fdev: fdev
    fsamp: samp_rate
    packet_len: packet_len
    threshold: detect_threshold_entry
  states: {}
- name: fsk_synchronization_0
  id: fsk_synchronization
  parameters:
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    hdr_len: hdr_len
    packet_len: packet_len
    tx_power: tx_power
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    oversample: '0'
    rf_freq: carrier_freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 62.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: data_rate*1
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: SDR signal
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: byte
    vlen: payload_len
  states: {}

connections:
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [fsk_demodulation_0, '0', fsk_packet_parser_0, '0']
- [fsk_onQuery_noise_estimation_0, noisePow, fsk_synchronization_0, noisePow]
- [fsk_packet_parser_0, '0', zeromq_pub_sink_0, '0']
- [fsk_packet_parser_0, '1', fsk_logger_0, '0']
- [fsk_packet_parser_0, payloadMetaData, fsk_logger_0, payloadMetaData]
- [fsk_preamble_detect_0, '0', fsk_synchronization_0, '0']
- [fsk_synchronization_0, '0', fsk_demodulation_0, '0']
- [fsk_synchronization_0, powerMetrics, fsk_logger_0, powerMetrics]
- [fsk_synchronization_0, syncMetrics, fsk_logger_0, syncMetrics]
- [limesdr_source_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', fsk_onQuery_noise_estimation_0, '0']
- [low_pass_filter_0, '0', fsk_preamble_detect_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
