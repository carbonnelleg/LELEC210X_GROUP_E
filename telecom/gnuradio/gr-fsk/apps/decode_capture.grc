options:
  parameters:
    author: UCLouvain
    generate_options: no_gui
    id: decode_capture
    output_language: python
    run_options: run
    title: LELEC2102 - Decode Capture
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: crc_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: detect_threshold
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: estimated_noise_power
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/4
  states: {}
- name: hdr_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: hdr_len+payload_len+crc_len
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*8
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/gauti/OneDrive - UCL/Documents/UCL - EPL/Master/Master 1 Q2/LELEC210X/LELEC210X_GROUP_E/telecom/gnuradio/gr-fsk/misc/fsk_capture.mat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: estimated_noise_power
    target: estimated_noise_power
  states: {}
- name: fsk_demodulation_0
  id: fsk_demodulation
  parameters:
    crc_len: crc_len
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    payload_len: payload_len
  states: {}
- name: fsk_logger_0
  id: fsk_logger
  parameters:
    meas_type: capture
    payload_len: payload_len
    print_metrics: 'True'
    print_payload: 'True'
    save_measurements: 'True'
  states: {}
- name: fsk_packet_parser_0
  id: fsk_packet_parser
  parameters:
    address: '[0,0,1,1,1,1,1,0,0,0,1,0,1,0,1,0,0,1,0,1,0,1,0,0,1,0,1,1,0,1,1,1]'
    crc_len: crc_len
    hdr_len: hdr_len
    payload_len: payload_len
  states: {}
- name: fsk_preamble_detect_0
  id: fsk_preamble_detect
  parameters:
    drate: data_rate
    enable: '1'
    fdev: fdev
    fsamp: samp_rate
    packet_len: packet_len
    threshold: detect_threshold
  states: {}
- name: fsk_synchronization_0
  id: fsk_synchronization
  parameters:
    N_Moose: '2'
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    hdr_len: hdr_len
    old_sync: 'False'
    packet_len: packet_len
    tx_power: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: data_rate+fdev
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: data_rate*1
    win: window.WIN_HAMMING
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: byte
    vlen: payload_len
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_var_to_msg_0, msgout, fsk_synchronization_0, noisePow]
- [fsk_demodulation_0, '0', fsk_packet_parser_0, '0']
- [fsk_packet_parser_0, '0', zeromq_pub_sink_0, '0']
- [fsk_packet_parser_0, '1', fsk_logger_0, '0']
- [fsk_packet_parser_0, payloadMetaData, fsk_logger_0, payloadMetaData]
- [fsk_preamble_detect_0, '0', fsk_synchronization_0, '0']
- [fsk_synchronization_0, '0', fsk_demodulation_0, '0']
- [fsk_synchronization_0, powerMetrics, fsk_logger_0, powerMetrics]
- [fsk_synchronization_0, syncMetrics, fsk_logger_0, syncMetrics]
- [low_pass_filter_0, '0', fsk_preamble_detect_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
