options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: fm_transmitter
    output_language: python
    title: FM transmitter
  states: {}

blocks:
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,2
    label: TX Baseband [MHz]
    type: real
    value: '446.094'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain [dB]
    min_len: '70'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: pa_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: PA Path
    label0: Auto
    label1: Band1
    label2: Band2
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '255'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 2e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: .../examples/guitar.wav
    repeat: 'True'
  states: {}
- name: limesdr_fpga_sink_0_0
  id: limesdr_fpga_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 2.5e6
    calibr_bandw_ch1: 2.5e6
    channel_mode: '0'
    dacVal: '180'
    digital_bandw_ch0: samp_rate
    digital_bandw_ch1: samp_rate
    filename: ''
    gain_dB_ch0: gain
    gain_dB_ch1: '1'
    length_tag_name: ''
    nco_freq_ch0: '0'
    nco_freq_ch1: '0'
    oversample: '0'
    pa_path_ch0: pa_path
    pa_path_ch1: '255'
    rf_freq: baseband*1e6
    samp_rate: samp_rate
    serial: ''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '2048'
    gui_hint: 2,0,1,2
    name: '"Transmiting data"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '25'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', limesdr_fpga_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
